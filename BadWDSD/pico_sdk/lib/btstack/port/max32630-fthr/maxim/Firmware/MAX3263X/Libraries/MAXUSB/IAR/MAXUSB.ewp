# IAR project MAXUSB.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: MAX3263x Maxim MAX3263x
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCIncludePath2: ..\include\core\arm; ..\include\core; ..\include\devclass; ..\include\enumerate; ..\..\CMSIS\Device\Maxim\MAX3263X\Include; ..\..\MAX3263XPeriphDriver\include
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  ILINK.IlinkOutputFile: MAXUSB.out
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  AARM.AUserIncludes: as above
  group core
    ../src/core/: usb_event.c
  group core/ARM
    ../src/core/arm/: usb.c
  group devclass
    ../src/devclass/: cdc_acm.c fifo.c fifo.h hid_kbd.c hid_raw.c
  group enumerate
    ../src/enumerate/: enumerate.c
